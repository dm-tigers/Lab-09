# Keil uVision project Blinky.uvprojx, settings and files
target Simulator (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1
  c include: .\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./startup_100mhz/: system_LPC17xx.c startup_LPC17xx.s
  group Core Code
    ./src/: core_cm3.c
  group Source Code
    ./src/: Blinky.c led1_ctrl.c
    ./: Serial.c
  group Documentation
    ./: Abstract.txt
target LPC1768 RAM (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: Blinky
  c flags: Optim=1
  asm define: NO_CRP
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target LPC1768 Flash (ARM-ADS)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.2.0
  cpu: as above
  output: Blinky
  c flags: Optim=1
  c include: ..\arm_prj01_Blinky_cmsis_system_tick;.\include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
software components: CMSIS:CORE 4.1.0
